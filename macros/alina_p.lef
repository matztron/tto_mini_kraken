# LEF generated for alina_p
VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO alina_p
   CLASS BLOCK ;
   FOREIGN alina_p 0 0 ;
   SIZE 15.600 BY 78.500 ;
   SYMMETRY X Y ;
END alina_p
